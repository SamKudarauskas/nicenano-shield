## config/boards/shields/CAD-Gaming/Kconfig.defconfig
```kconfig
if SHIELD_CADGaming

config ZMK_KEYBOARD_NAME
    default "Custom keyboard"
endif
```
